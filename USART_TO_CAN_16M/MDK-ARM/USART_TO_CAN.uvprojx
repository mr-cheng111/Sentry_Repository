# Keil uVision project USART_TO_CAN.uvprojx, settings and files
target USART_TO_CAN (6150000::V6.15::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x200027FF) IROM(0x8000000-0x8007FFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: USART_TO_CAN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103x6
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Bsp;../Task;../Behaviour;../MDK-ARM
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Application/MDK-ARM
    ./: startup_stm32f103x6.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Bsp
    ../Bsp/: bsp_can.c bsp_Referee.c CRC8_CRC16.c
  group Task
    ../Behaviour/: Referee_Behaviour.c
    ./: Referee_CAN.c
software components: CMSIS:CORE 5.5.0
